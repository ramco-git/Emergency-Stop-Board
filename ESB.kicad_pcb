# Repository ramco-git/Emergency-Stop-Board

File README.md:

# Emergency-Stop-Board　
パワーリレーDG85Bを使用した、駆動電源管理ボードです。

| 機能 | 個数 | ピンアサイン | コネクタ | 備考 |
|-:|-|-|-|-|
| 電源入力 | 1 | GND(1ピン) 入力+(2ピン) | ディーンズコネクタ(T型コネクタ) | |
| 電源出力 | 5 | GND(1ピン) 出力+(2ピン) | XT60,ディーンズコネクタ(T型コネクタ) | |
| 制御電源 | 1 | 12V(1ピン) 5V(2ピン) GND(3ピン) | B03B-SXH | 制御電源と駆動電源のGNDは絶縁されている |
| 非常停止入力 | 3 |

## KiCad design ESB.kicad_pcb

Parts:
C1, C3: 1u_1608; C_0603_1608Metric
C2, C4: 0.47_2012; C_0805_2012Metric
C5, C8: 0.1u~0.22u_1608; C_0603_1608Metric
C6, C7: 22u_2012; C_0805_2012Metric
D1, D7, D8: LED_GREEN; LED_0603_1608Metric
D2, D9, D10: LED_RED; LED_0603_1608Metric
D3, D4, D5, D6: D; D_SOD-123
H1, H2, H3, H4: MountingHole; MountingHole_M3_FBMask
J1, J2, J3, J4, J5: T/XT メス; AMASS_XT60-F_1x02_P7.20mm_Vertical
J6, J7: Conn_01x01; PCB-55(M3)
J8: Screw_Terminal_01x02; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
J9, J10, J14: XA_3; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J11: Pin-Hedder; PinSocket_1x02_P2.54mm_Vertical
J12: DEANS_オス
J13: XH_3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Q1, Q2: Q_NMOS_Depletion_GSD; SOT-23-3
R1, R11: 470; R_0603_1608Metric
R2, R3: 2.5K~; R_0603_1608Metric
R4, R5: 1K~10K; R_0603_1608Metric
R6, R8: 500~1K; R_0603_1608Metric
R7: ソフトスタート用 5Ω; R_Axial_Power_L25.0mm_W9.0mm_P27.94mm
R9, R10, R13: 470~; R_0603_1608Metric
R12: 1K~; R_0603_1608Metric
RV1: R_Potentiometer; Potentiometer_Runtron_RM-065_Vertical
Relay1: Relay_SPDT; 943-1C-xxDS
Relay2: DG85_7011
U1: MOCD217M; SOIC-8_3.9x4.9mm_P1.27mm
U2: 74HC02; SO-14_5.3x10.2mm_P1.27mm
U3: LED_Digital_VoltageSenser
U4: L78L12_SOT89; SOT-89-3
U5: 74HC14; CERDIP-14_W7.62mm_SideBrazed

Connections:
+5V: C5.1, C7.1, C8.1, D10.2 (A), J13.2, R4.1, R5.1, U2.14 (VCC), U5.13, U5.14 (VCC)
+12VA: C6.1, D3.1 (K), D6.1 (K), D9.2 (A), J13.1, Relay1.A1, Relay2.86 (C)
/BT_IN: J12.2, R3.2, R7.2, Relay2.87 (NO)
/BT_OUT: C2.1, J1.2, J2.2, J3.2, J4.2, J5.2, R2.1, Relay1.14, Relay2.30 (COM), U3.3 (Voltage_IN), U4.3 (IN)
/MAIN_Relay-GATE: D7.2 (A), Q2.1 (G), U5.6
/SoftStart_Relay-GATE: D8.2 (A), Q1.1 (G), U2.13
/States_OUT: D4.1 (K), R6.1, R11.2, U2.2, U2.3, U2.4
GND: C2.2, C4.2, D1.1 (K), D2.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1, J12.1, U3.1 (GND), U4.2 (GND)
GNDA: C1.2, C3.2, C5.2, C6.2, C7.2, C8.2, J7.1 (Pin_1_1), J8.2, J9.3, J11.1, J13.3, Q1.2 (S), Q2.2 (S), R9.2, R10.2, R12.2, R13.2, U1.4, U1.7, U2.7 (GND), U5.7 (GND)
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R3.1
unnamed: D3.2 (A), Q1.3 (D), Relay1.A2
unnamed: C3.1, D4.2 (A), RV1.3, U5.1
unnamed: C1.1, D5.2 (A), R8.1, U5.9
unnamed: D5.1 (K), R8.2, U5.4
unnamed: D6.2 (A), Q2.3 (D), Relay2.85 (C)
unnamed: D7.1 (K), R9.1
unnamed: D8.1 (K), R10.1
unnamed: D9.1 (K), R12.1
unnamed: D10.1 (K), R13.1
unnamed: J6.1 (Pin_1_1), J8.1, J9.2, R4.2, U2.6
unnamed: J10.2, R1.1
unnamed: J10.3, U1.2
unnamed: J11.2, R5.2, U1.8, U2.5
unnamed: J14.2, U1.6
unnamed: J14.3, U1.5
unnamed: R1.2, U1.1
unnamed: R6.2, RV1.1, RV1.2
unnamed: R7.1, Relay1.11
unnamed: R11.1, U1.3
unnamed: U2.1, U2.12
unnamed: U2.8, U2.9, U5.8
unnamed: U2.10, U2.11
unnamed: C4.1, U3.2 (VDD), U4.1 (OUT)
unnamed: U5.2, U5.3, U5.5
unnamed: U5.11, U5.12

Notes on the sheet:
1/15 内蔵
オープンドレイン式ステータス出力
出力コネクタ

Board: 2 copper layers, 100.0 x 50.0 mm, 59 parts (14 on the bottom side), 36 nets.
